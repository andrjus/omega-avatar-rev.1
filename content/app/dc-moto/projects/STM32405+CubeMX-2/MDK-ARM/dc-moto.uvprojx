# Keil uVision project dc-moto.uvprojx, settings and files
target dc-moto (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: dc-moto_rev_3_2 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xxx,USE_HAL_DRIVER,STM32F405xx, BOARD_MEXO_FLOW_DEFAULT_ADDRESS=0x5
  c include: ..\..\..\source\common\vercion\default;  ..\..\..\source\common;  ..\..\..\..\..\reference\robosd-ref;  ..\..\..\..\..\reference\robosd-ref\core\platform\keil5+cpp11;  ../Core/Inc;  ..\..\..\source\platform\STM32405+CubeMX;  ../Drivers/STM32F4xx_HAL_Driver/Inc;  ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;  ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group source/common
    ../../../source/common/: board.flow.common.h board.flow.tuning.h board_common.h joint_config.h joint_settings.h dc-moto.flow.proto.h dc-moto.cpp dc-moto.hpp dc-moto.flow.proto.cpp robosd.cpp robosd.hpp
  group source/common/vercion/default
    ../../../source/common/vercion/default/: board_options.h joint_settings_tuning.h
  group robosd/mexo/board
    ../../../../../reference/robosd-ref/mexo/board/dcmoto/: dcmoto_joint.cpp dcmoto_joint.hpp
    ../../../../../reference/robosd-ref/mexo/board/: board+flow+uart+can-rev3.cpp board+flow+uart+can-rev3.hpp
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c can.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group source/platform
    ../../../source/platform/STM32405+CubeMX/: dc-moto_perefery.cpp free_master_cfg_tuning.h mexo_options.h robosd_app_tuning.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group source/common/vercion/left-hand
    ../../../source/common/vercion/left-hand/: board_options.h joint_settings_tuning.h
target z-axis-1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: as above
  output: z-axis-1 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xxx, BOARD_KIND = BOARD_MOTOR_ENCO_DIR
  c include: ..\..\..\source\common\vercion\default;..\..\..\source\common;..\..\..\..\..\reference\robosd-ref;..\..\..\..\..\reference\robosd-ref\core\platform\keil5+cpp11;../Core/Inc;..\..\..\source\platform\STM32405+CubeMX;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0xfc000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target z-axis-left (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: as above
  output: z-axis-left +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6LangP=3 wLevel=2
  c define: as above
  c include: ..\..\..\source\common\vercion\left-hand;..\..\..\source\common;..\..\..\..\..\reference\robosd-ref;..\..\..\..\..\reference\robosd-ref\core\platform\keil5+cpp11;../Core/Inc;..\..\..\source\platform\STM32405+CubeMX;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0xfc000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.3.0
