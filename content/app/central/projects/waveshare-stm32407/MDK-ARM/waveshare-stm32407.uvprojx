# Keil uVision project waveshare-stm32407.uvprojx, settings and files
target right-waveshare-stm32407 (6160000::V6.16::ARMCLANG)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: right-waveshare-stm32407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,RIGHT_HAND, POINT_IN_THE_WIRST
  c misc: -Wc++14-extensions
  c include: ../Core/Inc;   ../Drivers/STM32F4xx_HAL_Driver/Inc;   ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;   ../Drivers/CMSIS/Include;   ../FATFS/Target;   ../FATFS/App;   ../Middlewares/Third_Party/FatFs/src;   ..\..\..\source\platform\waveshare-stm32f407;   ..\..\..\source\common;   ..\..\..\source\common\vercion\default;   ../LWIP/App;   ../LWIP/Target;   ../Middlewares/Third_Party/LwIP/src/include;   ../Middlewares/Third_Party/LwIP/system;   ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;   ../Middlewares/Third_Party/LwIP/src/include/lwip;   ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;   ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;   ../Middlewares/Third_Party/LwIP/src/include/lwip/prot;   ../Middlewares/Third_Party/LwIP/src/include/netif;   ../Middlewares/Third_Party/LwIP/src/include/compat/posix;   ../Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa;   ../Middlewares/Third_Party/LwIP/src/include/compat/posix/net;   ../Middlewares/Third_Party/LwIP/src/include/compat/posix/sys;   ../Middlewares/Third_Party/LwIP/src/include/compat/stdc;   ../Middlewares/Third_Party/LwIP/system/arch;   ../USB_DEVICE/App;   ../USB_DEVICE/Target;   ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;   ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;   ..\..\..\..\..\reference\robosdpp-ref\;   ..\..\..\..\..\reference\robosdpp-ref\core\platform\keil+cpp6;   ..\..\..\..\..\reference\inlib-ref;   ..\..\..\..\..\reference\json-ref\
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c fsmc.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_eth.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_can.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: user_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
  group app/source/common
    ../../../source/common/: avatar-central.cpp avatar-central.hpp avatar-central-common.h avatar-central-front.hpp dynamixel_controltable.inc.hpp
    ../../../source/platform/waveshare-stm32f407/: avatar-central-perephery.cpp
  group app/source/common/vercion/default
    ../../../source/common/vercion/default/: avatar-central-option.h
  group app/source/platform/w-stm32f407
    ../../../source/platform/waveshare-stm32f407/: stm32_bsp_nand.c stm32_bsp_nand.h robosd_app_tuning.hpp
    ../../../../../reference/json-ref/: jsonsl.c
  group Application/User/LWIP/Target
    ../LWIP/Target/: ethernetif.c
  group Application/User/LWIP/App
    ../LWIP/App/: lwip.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c ecp.c
    ../Middlewares/Third_Party/LwIP/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Middlewares/Third_Party/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
    ../Middlewares/Third_Party/LwIP/src/apps/tftp/: tftp_server.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group robosd/core
    ../../../../../reference/robosdpp-ref/core/: robosd_common.hpp robosd_list.hpp robosd_log.cpp robosd_log.hpp robosd_system.hpp robosd_backend.hpp robosd_delegat.hpp robosd_frontend.hpp robosd_ini.hpp robosd_lambda.hpp robosd_string.hpp robosd_system_module_reg.hpp robosd_system_native.hpp robosd_tran.h robosd_system.cpp robosd_string.cpp robosd_ini_parser.cpp robosd_ini_parser.h robosd_app.cpp robosd_system_native.cpp robosd_backend.cpp robosd_frontend.cpp robosd_ring_buf.hpp robosd_convert.cpp robosd_convert.hpp
    ../../../../../reference/robosdpp-ref/core/platform/keil+cpp6/: robosd_target.hpp
    ../../../../../reference/robosdpp-ref/net/: robosd_net_master.hpp
  group robosd/net
    ../../../../../reference/robosdpp-ref/net/: robosd_net_master.hpp robosd_net_trafic.hpp robosd_net_trafic.cpp
target left-waveshare-stm32407 (6160000::V6.16::ARMCLANG)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: as above
  output: left-waveshare-stm32407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,LEFT_HAND, POINT_IN_THE_WIRST
  c misc: -Wc++14-extensions
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.4.0
